# Keil uVision project freeRtosStm32f105.uvprojx, settings and files
target freeRtosStm32f105 (ARM-ADS)
  device: STM32F105RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: freeRtosStm32f105 +hex
  AfterMake: ..\Binary\hex2bin ..\Obj\freeRtosStm32f105.hex
  c flags: Optim=4
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: ..\BoardCfg;..\StmLib\STM32F10x_StdPeriph_Driver\inc;..\StmLib\CMSIS;..\FreeRTOS\include;..\FreeRTOS\portable\Keil\ARM_CM3;..\FreeRTOS\FreeRTOS-Plus-CLI;..\Embedded\utilities;..\Embedded\drivers\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StmLib
    ../StmLib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../StmLib/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ../StmLib/CMSIS/: core_cm3.c core_cm3.h
  group FreeRTOS
    ../FreeRTOS/: list.c queue.c tasks.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/Keil/ARM_CM3/: port.c portmacro.h
    ../FreeRTOS/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../FreeRTOS/FreeRTOS-Plus-CLI/: FreeRTOS_CLI.c
  group BoardCfg
    ../BoardCfg/: FreeRTOSConfig.h startup_stm32f10x_cl.s stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h
  group Embedded
    ../Embedded/utilities/: defines.h includes.h fifo.c fifo.h
    ../Embedded/platform/: main.c main.h version.c version.h
  group Drivers
    ../Embedded/drivers/inc/: driver_uart1.h driver_uart2.h uart_common.h drivers.h
    ../Embedded/drivers/src/: driver_uart1.c driver_uart2.c uart_common.c drivers.c
  group Apps
    ../Embedded/apps/: uart_driver_test.c uart_driver_test.h
