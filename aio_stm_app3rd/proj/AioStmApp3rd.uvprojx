# Keil uVision project AioStmApp3rd.uvprojx, settings and files
target AioStmApp3rd (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AioStmApp3rd +hex
  AfterMake: ..\binary\hex2bin.exe ..\obj\AioStmApp3rd.hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\lib\STM32F10x_StdPeriph_Driver\inc;..\lib\CMSIS\CM3\CoreSupport;..\AioStmCfg;..\FreeRTOS\include;..\FreeRTOS\portable\Keil\ARM_CM3;..\embedded\utilities;..\embedded\drivers\inc
  memory RVCT4: ROM 0x8000000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StmLib
    ../lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../lib/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group CMSIS
    ../lib/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
  group AioStmCfg
    ../AioStmCfg/: FreeRTOSConfig.h startup_stm32f10x_md.s stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h
  group FreeRTOS
    ../FreeRTOS/: list.c queue.c tasks.c
    ../FreeRTOS/portable/Keil/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group Embedded
    ../embedded/platform/: main.c version.c io_default.c
    ../embedded/apps/: app_led.c app_serial.c app_interAdc.c app_i2c.c app_ecg.c app_nibp.c app_power.c
    ../embedded/drivers/src/: driver_led.c driver_uart.c driver_interAdc.c i2c_it.c driver_i2c.c ecg_api.c driver_ecg.c driver_nibp.c nibp_api.c
